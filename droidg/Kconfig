## droidg/Kconfig
```kconfig
config SECURITY_DROIDG
	bool "DroidGuardian"
	default n
	help
	  DroidGuardian Module. Intercepts outgoing Internet traffic.
```
